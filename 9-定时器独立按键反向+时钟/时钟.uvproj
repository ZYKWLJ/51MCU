# Keil uVision project 时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: 时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\3software\keil\C51\INC\Atmel
  group Source Group 1
    ./: main.c lcd1602.c lcd1602.h
