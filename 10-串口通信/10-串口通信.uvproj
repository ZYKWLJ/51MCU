# Keil uVision project 10-串口通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: Nexar TSK51 Altium
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF) CLOCK(44000000)
  output: 10-串口通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\3software\keil\C51\INC\Atmel
  group Source Group 1
    ./: main.c lcd1602.c lcd1602.h UART.c UART.h
