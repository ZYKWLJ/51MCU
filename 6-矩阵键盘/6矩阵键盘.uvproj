# Keil uVision project 6矩阵键盘.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: 6矩阵键盘 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\3software\keil\C51\INC\Atmel
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h matrix.c matrix.h delay.c delay.h
