# Keil uVision project project3-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: project3-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\3software\keil\C51\INC\Atmel
  group Source Group 1
    ./: main.c
